# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Vertical Layer/: Datatypes.h Macros.h
    ../GPIO/: GPIO.c GPIO_cfg.h GPIO_interface.h GPIO_private.h
    ./: main.c UART.c UART_cfg.h UART_interface.h UART_private.h
    ../RCC/: RCC.c RCC_cfg.h RCC_interface.h RCC_private.h
